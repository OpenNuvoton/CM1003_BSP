# Keil uVision project Project_temp.uvproj, settings and files
target Project_temp (MCS-51)
  device: CM1003DL8AE Nuvoton
  cpu: IRAM(0 - 0xFF) IROM(0 - 0x3FFF)  XRAM(0 - 0x3FF) CLOCK(24000000)
  output: Project_temp +hex
  AfterMake: $K\C51\NULink\Hex2Bin.exe .\output\@L.hex
  c flags: Optimize=7 SizeSpeed=1
  c include: ..\..\..\..\Library\Device\Include;..\..\..\..\Library\StdDriver\inc
  link misc: REMOVEUNUSED
  group Source
    ../: main.c
  group Library
    ../../../../Library/StdDriver/src/: sys.c uart.c common.c adc.c bod.c delay.c eeprom.c eeprom_sprom.c i2c.c IAP.c IAP_SPROM.c isr.c pwm0.c pwm123.c spi.c uart2.c uart3.c uart4.c wkt.c gpio.c timer.c wdt.c
  group Startup
    ../../../../Library/Startup/KEIL/: STARTUP.A51
