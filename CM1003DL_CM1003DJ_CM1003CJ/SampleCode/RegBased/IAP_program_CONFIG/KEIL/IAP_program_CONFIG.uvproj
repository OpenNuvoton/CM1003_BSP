# Keil uVision project IAP_program_CONFIG.uvproj, settings and files
target IAP_program_CONFIG (MCS-51)
  device: CM1003DL8AE Nuvoton
  cpu: IRAM(0 - 0xFF) IROM(0 - 0x7FFF)  XRAM(0 - 0x7FF) CLOCK(24000000)
  output: IAP_program_CONFIG +hex
  AfterMake: $K\C51\NULink\Hex2Bin.exe .\output\@L.hex
  c flags: Optimize=7 SizeSpeed=1
  c include: ..\..\..\..\Library\Device\Include;..\..\..\..\Library\StdDriver\inc
  link misc: REMOVEUNUSED
  group Source
    ../: main.c
  group Library
    ../../../../Library/StdDriver/src/: sys.c common.c delay.c iap.c uart.c
  group Startup
    ../../../../Library/Startup/Keil/: STARTUP.A51
