# Keil uVision project ADC_Compare_Mode0.uvproj, settings and files
target ADC_Compare_Mode0 (MCS-51)
  device: CM1003DL8AE Nuvoton
  cpu: IRAM(0 - 0xFF) IROM(0 - 0xFFFF)  XRAM(0 - 0xFFF) CLOCK(24000000)
  output: ADC_Compare_Mode0 +hex
  AfterMake: $KC51\NULink\Hex2Bin.exe .\output\@L.hex
  c flags: Optimize=7 SizeSpeed=1
  c include: ..\..\..\..\Library\Device\Include;..\..\..\..\Library\StdDriver\inc
  link misc: REMOVEUNUSED
  group Source
    ../: main.c
  group Common
    ../../../../Library/StdDriver/src/: sys.c delay.c adc.c common.c uart.c
  group Startup
    ../../../../Library/Startup/Keil/: STARTUP.A51
