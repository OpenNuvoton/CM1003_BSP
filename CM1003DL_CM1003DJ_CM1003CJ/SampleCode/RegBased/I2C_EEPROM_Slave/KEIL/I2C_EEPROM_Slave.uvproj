# Keil uVision project I2C_EEPROM_Slave.uvproj, settings and files
target I2C_EEPROM_Slave (MCS-51)
  device: CM1003DL8AE Nuvoton
  cpu: IRAM(0 - 0xFF) IROM(0 - 0x47FF)  XRAM(0 - 0x2FF) CLOCK(16000000)
  output: I2C_EEPROM_Slave +hex
  AfterMake: $K\C51\NULink\Hex2Bin.exe .\output\@L.hex
  c flags: Optimize=8 SizeSpeed=1
  c include: ..\..\..\..\Library\Device\Include;..\..\..\..\Library\StdDriver\inc
  link misc: REMOVEUNUSED
  group Source
    ../: main.c
  group Library
    ../../../../Library/StdDriver/src/: common.c eeprom.c i2c.c sys.c uart.c
  group Startup
    ../../../../Library/Startup/Keil/: STARTUP.A51
