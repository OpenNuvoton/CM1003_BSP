# Keil uVision project ISP_I2C.uvproj, settings and files
target ISP_I2C (MCS-51)
  device: CM1003CF2AE Nuvoton
  cpu: IRAM(0 - 0xFF) IROM(0 - 0x3FFF)  XRAM(0 - 0x3FF) CLOCK(24000000)
  output: ISP_I2C +hex
  AfterMake: $KC51\NULink\Hex2Bin.exe .\output\@L.hex
  c flags: Optimize=7 SizeSpeed=1
  c include: ..\..\..\..\Library\Device\Include;..\..\..\..\Library\StdDriver\inc;..\include
  link misc: REMOVEUNUSED
  group Source
    ../: main.c isp_i2c.c
  group Startup
    ../../../../Library/Startup/Keil/: STARTUP.A51
