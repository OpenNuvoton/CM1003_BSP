# Keil uVision project ISP_UART0.uvproj, settings and files
target ISP_UART0 (MCS-51)
  device: CM1003CF2AE Nuvoton
  cpu: IRAM(0 - 0xFF) IROM(0 - 0x7FFF)  XRAM(0 - 0x3FF) CLOCK(24000000)
  output: ISP_UART0 +hex
  AfterMake: $KC51\NULink\Hex2Bin.exe .\output\@L.hex
  c flags: Optimize=7 SizeSpeed=1
  c include: ..\..\..\..\Library\Device\Include;..\..\..\..\Library\StdDriver\inc;..\include
  link misc: REMOVEUNUSED
  group Source
    ../: main.c isp_uart0.c
  group Startup
    ../../../../Library/Startup/Keil/: STARTUP.A51
