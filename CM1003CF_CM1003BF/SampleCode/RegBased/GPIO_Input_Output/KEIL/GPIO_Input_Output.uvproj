# Keil uVision project GPIO_Input_Output.uvproj, settings and files
target GPIO_Input_Output (MCS-51)
  device: CM1003CF2AE Nuvoton
  cpu: IRAM(0 - 0xFF) IROM(0 - 0x7FFF)  XRAM(0 - 0x3FF) CLOCK(24000000)
  output: GPIO_Input_Output +hex
  AfterMake: $KC51\NULink\Hex2Bin.exe .\output\@L.hex
  c flags: Optimize=1 SizeSpeed=1
  c include: ..\..\..\..\Library\Device\Include;..\..\..\..\Library\StdDriver\inc
  link misc: REMOVEUNUSED
  group Source
    ../: main.c
  group Library
    ../../../../Library/StdDriver/src/: common.c sys.c uart.c delay.c
  group Startup
    ../../../../Library/Startup/KEIL/: STARTUP.A51
