# Keil uVision project Timer2_Interrupt.uvproj, settings and files
target Timer2_Interrupt (MCS-51)
  device: CM1003CF2AE Nuvoton
  cpu: IRAM(0 - 0xFF) IROM(0 - 0x7FFF)  XRAM(0 - 0x3FF) CLOCK(24000000)
  output: Timer2_Interrupt +hex
  AfterMake: $KC51\NULink\Hex2Bin.exe .\output\@L.hex
  c flags: Optimize=8 SizeSpeed=1
  c include: ..\..\..\..\Library\Device\Include;..\..\..\..\Library\StdDriver\inc
  link misc: REMOVEUNUSED
  group Source
    ../: main.c
  group Common
    ../../../../Library/StdDriver/src/: common.c uart.c timer.c
  group Startup
    ../../../../Library/Startup/KEIL/: STARTUP.A51
