# IAR project IAP_Dataflash_EEPROM_SPROM.ewp, settings and files
configuration Debug (8051, debug)
  General.OGChipSelectMenu: CM1003CFxAE CM1003CFxAE
  ICC8051.CCDefines: FOSC_160000=1
  ICC8051.OCCDataMemoryModel: 1
  ICC8051.OCCCodeMemoryModel: 1
  ICC8051.CCIncludePath2: ..\..\..\..\Library\Device\Include; ..\..\..\..\Library\StdDriver\inc
  ICC8051.CCOptLevel: 0
  ICC8051.CCOptStrategy: 0
  ICC8051.IccLang: 0
  A8051.ADefines: FOSC_160000
  postbuild: cmd /C ""$TOOLKIT_DIR$\..\..\..\Nuvoton Tools\Nu-Link_IAR\Hex2Bin.exe" "Debug\Exe\$TARGET_BNAME$.a51""
  XLINK.XclFile: $TOOLKIT_DIR$\config\devices\Nuvoton\lnk51ew_CM1003CFxAE.xcl
configuration Release (8051)
  as the first configuration, except:
  General.RTConfigPath: xxx.h
  ICC8051.CCDefines: NDEBUG
  ICC8051.CCOptLevel: 3
  ICC8051.CCOptStrategy: 1
  XLINK.XclFile: lnk0t.xcl
  group (top)
    ../: main.c
  group Library
    ../../../../Library/StdDriver/src/: common.c eeprom_sprom.c putchar.c sys.c uart.c
  group Startup
    ../../../../Library/Startup/IAR/: cstartup.s51
