# Keil uVision project IAP_Dataflash_EEPROM_SPROM.uvproj, settings and files
target IAP_Dataflash_EEPROM_SPROM (MCS-51)
  device: CM1003CF2AE Nuvoton
  cpu: IRAM(0 - 0xFF) IROM(0 - 0x1FFF)  XRAM(0 - 0x3FF) CLOCK(16000000)
  output: IAP_Dataflash_EEPROM_SPROM +hex
  AfterMake: $KC51\NULink\Hex2Bin.exe .\output\@L.hex
  c flags: Optimize=4 SizeSpeed=1
  c include: ..\..\..\..\Library\Device\Include;..\..\..\..\Library\StdDriver\inc
  link misc: REMOVEUNUSED
  group Source
    ../: main.c
  group Library
    ../../../../Library/StdDriver/src/: sys.c uart.c common.c eeprom_sprom.c
  group Startup
    ../../../../Library/Startup/KEIL/: STARTUP.A51
