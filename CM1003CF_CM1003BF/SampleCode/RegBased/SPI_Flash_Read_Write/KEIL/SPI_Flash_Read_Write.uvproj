# Keil uVision project SPI_Flash_Read_Write.uvproj, settings and files
target SPI_Flash_Read_Write (MCS-51)
  device: CM1003CF2AE Nuvoton
  cpu: IRAM(0 - 0xFF) IROM(0 - 0x3FFF)  XRAM(0 - 0x3FF) CLOCK(24000000)
  output: SPI_Flash_Read_Write +hex
  AfterMake: $KC51\NULink\Hex2Bin.exe .\output\@L.hex
  c flags: Optimize=7 SizeSpeed=1
  c include: ..\..\..\..\Library\Device\Include;..\..\..\..\Library\StdDriver\inc
  link misc: REMOVEUNUSED
  group Source
    ../: main.c
  group Library
    ../../../../Library/StdDriver/src/: spi.c common.c sys.c uart.c
  group Startup
    ../../../../Library/Startup/Keil/: STARTUP.A51
