# Keil uVision project I2C_EEPROM_Master_Polling.uvproj, settings and files
target I2C_EEPROM_Master_Polling (MCS-51)
  device: CM1003CF2AE Nuvoton
  cpu: IRAM(0 - 0xFF) IROM(0 - 0x3FFF)  XRAM(0 - 0x3FF) CLOCK(24000000)
  output: I2C_EEPROM_Master_Polling +hex
  AfterMake: $KC51\NULink\Hex2Bin.exe .\output\@L.hex
  c flags: Optimize=7 SizeSpeed=1
  c include: ..\..\..\..\Library\Device\Include;..\..\..\..\Library\StdDriver\inc
  link misc: REMOVEUNUSED
  group Source
    ../: main.c
  group Library
    ../../../../Library/StdDriver/src/: sys.c uart.c common.c
  group Startup
    ../../../../Library/Startup/Keil/: STARTUP.A51
