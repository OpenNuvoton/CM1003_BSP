# Keil uVision project UART1_Printf.uvproj, settings and files
target UART1_Printf (MCS-51)
  device: CM1003CF2AE Nuvoton
  cpu: IRAM(0 - 0xFF) IROM(0 - 0x3FFF)  XRAM(0 - 0x3FF) CLOCK(24000000)
  output: UART1_Printf +hex
  AfterMake: $KC51\NULink\Hex2Bin.exe .\output\@L.hex
  c flags: Optimize=7 SizeSpeed=1
  c define: FOSC_160000
  c include: ..\..\..\..\Library\Device\Include;..\..\..\..\Library\StdDriver\inc
  link misc: REMOVEUNUSED
  group Source
    ../: main.c putchar.c
  group Library
    ../../../../Library/StdDriver/src/: sys.c uart.c delay.c common.c
  group Startup
    ../../../../Library/Startup/Keil/: STARTUP.A51
